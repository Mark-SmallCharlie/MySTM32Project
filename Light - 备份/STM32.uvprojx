# Keil uVision project STM32.uvprojx, settings and files
target STM32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\Library\inc;.\System;.\User;.\STM32f10x_it;.\Library\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ./ASM/: startup_stm32f10x_hd.s
  group Library
    ./Library/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_exti.c misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c
  group System
    ./System/: core_cm3.c system_stm32f10x.c
  group User
    ./: main.c
    ./User/: delay.c key.c led.c exti.c timer.c dht11.c usart.c adc.c bh1750.c
  group STM32f10x_it
    ./STM32f10x_it/: stm32f10x_it.c
